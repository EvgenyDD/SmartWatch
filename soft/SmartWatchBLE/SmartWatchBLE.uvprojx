# Keil uVision project SmartWatchBLE.uvprojx, settings and files
target BLE (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_MAGIC +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: NRF51 S110 BLE_STACK_SUPPORT_REQD USE_WITH_SOFTDEVICE
  c misc: --c99
  c include: .\nRF51_SDK_9.0.0_2e23562\components\libraries\util;.\nRF51_SDK_9.0.0_2e23562\components\softdevice\s110\headers;.\nRF51_SDK_9.0.0_2e23562\components\softdevice\common\softdevice_handler;.\nRF51_SDK_9.0.0_2e23562\components\ble\common;.\nRF51_SDK_9.0.0_2e23562\components\ble\ble_advertising;.\nRF51_SDK_9.0.0_2e23562\components\ble\ble_services\ble_bas;.\nRF51_SDK_9.0.0_2e23562\components\ble\ble_services\ble_hrs;.\nRF51_SDK_9.0.0_2e23562\components\ble\ble_services\ble_dis;.\nRF51_SDK_9.0.0_2e23562\components\drivers_nrf\pstorage;.\nRF51_SDK_9.0.0_2e23562\components\drivers_nrf\pstorage\config;.\nRF51_SDK_9.0.0_2e23562\components\libraries\trace;.\nRF51_SDK_9.0.0_2e23562\components\ble\device_manager;.\nRF51_SDK_9.0.0_2e23562\components\ble\device_manager\config;.\nRF51_SDK_9.0.0_2e23562\components\libraries\timer;.\nRF51_SDK_9.0.0_2e23562\components\drivers_nrf\hal;.\RTE\config;.\RTE\CMSIS;.\RTE\CMSIS\BMP180;.\RTE\CMSIS\LSM303;.\RTE\CMSIS\SSD1306;.\nRF51_SDK_9.0.0_2e23562\components\ble\ble_services\ble_dfu;.\nRF51_SDK_9.0.0_2e23562\components\libraries\bootloader_dfu;.\nRF51_SDK_9.0.0_2e23562\components\libraries\crc16;.\nRF51_SDK_9.0.0_2e23562\components\libraries\scheduler;.\nRF51_SDK_9.0.0_2e23562\components\ble\ble_services\ble_cts_c;.\nRF51_SDK_9.0.0_2e23562\components\ble\ble_db_discovery;.\nRF51_SDK_9.0.0_2e23562\components\drivers_nrf\rng;.\nRF51_SDK_9.0.0_2e23562\components\drivers_nrf\common;.\nRF51_SDK_9.0.0_2e23562\components\libraries\fifo;..\SmartWatchBLE;.\RTE\Application
  asm define: S110 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ./RTE/Application/: main.c BLE_App.c BLE_Indicator.c btn_ble.c games.c menu.c resources.c UI.c dispatcher.c alarm.c
    ./RTE/config/: Periph.c
    ./: shadow_logic.c
  group nRF_SoftDevice
    ./nRF51_SDK_9.0.0_2e23562/components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/ble_advertising/: ble_advertising.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/device_manager/: device_manager_peripheral.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/ble_services/ble_bas/: ble_bas.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/ble_services/ble_dfu/: ble_dfu.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/ble_services/ble_dis/: ble_dis.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/ble_services/ble_cts_c/: ble_cts_c.c
    ./nRF51_SDK_9.0.0_2e23562/components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_Libraries
    ./nRF51_SDK_9.0.0_2e23562/components/libraries/util/: app_error.c nrf_assert.c
    ./nRF51_SDK_9.0.0_2e23562/components/libraries/trace/: app_trace.c
    ./RTE/CMSIS/: nrf_pwm.c light.c sound.c spi_master.c string.c timework.c twi_hw_master_sd.c
    ./nRF51_SDK_9.0.0_2e23562/components/drivers_nrf/hal/: nrf_adc.c nrf_delay.c
    ./nRF51_SDK_9.0.0_2e23562/components/drivers_nrf/rng/: nrf_drv_rng.c
  group nRF_Drivers
    ./nRF51_SDK_9.0.0_2e23562/components/drivers_nrf/pstorage/: pstorage.c
    ./RTE/CMSIS/SSD1306/: DefaultFonts.c SSD1306.c
    ./RTE/CMSIS/BMP180/: BMP180.c
    ./RTE/CMSIS/LSM303/: LSM303.c LSM303_process.c
software components: CMSIS:CORE 4.1.0, Device:Startup 7.2.1
